File: main/ir_led.kicad_sch (KiCad schematic)
At the start: 6 parts, among them Q7 PMF250XNEX

Commit message: feat: update main board
Parts:
- R23: value 5.6 -> 10
