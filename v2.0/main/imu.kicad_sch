File: v2.0/main/imu.kicad_sch (KiCad schematic)
At the start: 4 parts, among them U3 ICM-20600

Commit message: feat: update pcb routing
Parts:
- renumbered C11 to C10, C12 to C11, C13 to C12
